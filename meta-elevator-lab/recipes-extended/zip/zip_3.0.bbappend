FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:class-target = " file://0001-install-the-already-built-zip-programs.patch"
